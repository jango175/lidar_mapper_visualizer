Commit message: change base_link position

File: lidar_mapper_visualizer/urdf/lidar_mapper_drone.urdf (robot description, URDF)
Before this commit: robot lidar_mapper_drone, 29 links, 28 joints
Joints:
- joint base_to_body_joint: origin xyz=0 0 0 rpy=3.14159 0 0 -> xyz=0 0 -0.015 rpy=3.14159 0 0
